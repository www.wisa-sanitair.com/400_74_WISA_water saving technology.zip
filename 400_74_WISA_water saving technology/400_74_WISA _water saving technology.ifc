Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2015-02-27T10:38:26
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 27 10:38:26 2015 * Host: PC-ARN-001 * Database: C:\Users\mdegans\AppData\Local\Temp\{64960149-991D-4470-980C-9D82C1F5ADDE}\ifc * Database version: 5507 * Database creation date: Fri Feb 27 10:38:24 2015 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Feb 27 10:38:24 2015 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 27 10:38:24 2015 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: R:\Revit 2014\02-Te controleren\Bibliotheken\IFC\400_74_WISA _water saving technology.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Graphics - Color: 0; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Pattern: -3000010
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Model Text:Model Text 1
In: Level 1
Identity Data - Subcategory: -2000151
Dimensions - Depth: 50 mm
Phasing - Phase Created: New Construction
Materials and Finishes - Material: WISA zwart
Constraints - Work Plane: Level : Level 1
Graphics - Horizontal Align: Left; Text: WATER SAVING TECHNOLOGY
Pset_BuildingElementProxyCommon - Reference: Model Text 1
Text - Text Size: 600 mm; Text Font: Arial; Italic: no; Bold: no

# IfcFlowTerminal: booster_wisa_18 liter booster, NLRS_52_PIA_UN_booster 18 liter_wisa:booster_wisa_18 liter booster:3534390
In: Level 1
Type - ElementType: booster_wisa_18 liter booster; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: NLRS_n6_PE_zwart
Text - NLRS_P_c01_omschrijving: c01_vwa; NLRS_P_c02_omschrijving: c02_vwa
General - NLRS_C_content_creator: WISA
Dimensions - NLRS_P_c02_diameter: 110 mm; NLRS_P_c01_diameter: 110 mm; Size: 110ø-110ø
Materials and Finishes - NLRS_C_materiaal: NLRS_n6_PE_zwart
Identity Data - URL: www.wisa-sanitair.com/nl/9100902000; NLRS_C_code_SfB_tabel1: 52.30; Assembly Description: algemeen (verzamelniveau); OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; NLRS_C_code_ETIM: EC010850; NLRS_C_description: 18 Liter Booster; Description: 18 Liter Booster; URL_ontwerpbrochure: www.wisa-sanitair.com/nl/9999000042; Manufacturer: WISA; Assembly Code: 3A(52.30); NLRS_C_type_comments: Booster; NLRS_C_code_gtin: 8711778049864; NLRS_C_revit_versie: 2014; NLRS_C_code_fabrikant_product: 9100902000; NLRS_C_model: Booster; NLRS_C_code_fabrikant_gln: 8711778000001; NLRS_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010850&ArtClassVersion=1; Type Comments: Booster; OmniClass Number: 23.45.00.00; Model: Booster; NLRS_C_code_STABU: 53.31; Mark: 21
Mechanical - NLRS_P_c02_volumestroom: 0 m3/s; NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Undefined
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Mechanical - Flow - Pressure Drop: 0
Insulation - Overall Size: 110 mmø-110 mmø; Insulation Thickness: 0
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: booster_wisa_one family booster, NLRS_52_PIA_UN_booster one family_wisa:booster_wisa_one family booster:3534438
In: Level 1
Type - ElementType: booster_wisa_one family booster; PredefinedType: USERDEFINED; Classification: 3A(52.30) algemeen (verzamelniveau) (UniFormat); Material: NLRS_n6_PE_zwart
Materials and Finishes - NLRS_C_materiaal: NLRS_n6_PE_zwart
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; NLRS_P_c02_volumestroom: 0 m3/s; System Classification: Undefined
General - NLRS_C_content_creator: WISA
Text - NLRS_P_c01_omschrijving: c01_vwa; NLRS_P_c02_omschrijving: c02_vwa
Dimensions - NLRS_P_c01_diameter: 110 mm; NLRS_P_c02_diameter: 110 mm; Size: 110ø-110ø
Identity Data - NLRS_C_code_gtin: 8711778066137; Type Comments: Booster; Assembly Description: algemeen (verzamelniveau); URL: www.wisa-sanitair.com/nl/9100902050; Description: One Family Booster; Manufacturer: WISA; NLRS_C_model: Booster; URL_ontwerpbrochure: www.wisa-sanitair.com/nl/9999000042; NLRS_C_code_ETIM: EC010850; NLRS_C_code_fabrikant_gln: 8711778000001; NLRS_C_code_STABU: 53.31; Assembly Code: 3A(52.30); Model: Booster; NLRS_C_description: One Family Booster; NLRS_C_revit_versie: 2014; NLRS_C_code_fabrikant_product: 9100902050; NLRS_C_code_SfB_tabel1: 52.30; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; NLRS_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010850&ArtClassVersion=1; NLRS_C_type_comments: Booster; OmniClass Number: 23.45.00.00; Mark: 22
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Mechanical - Flow - Pressure Drop: 0
Insulation - Overall Size: 110 mmø-110 mmø; Insulation Thickness: 0
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: diepspoel_wisa_nautic wandcloset, NLRS_74_PF_FB_wandcloset diepspoel nautic 5530_wisa:diepspoel_wisa_nautic wandcloset:3527363
In: Level 1
Type - ElementType: diepspoel_wisa_nautic wandcloset; PredefinedType: TOILETPAN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: NLRS_g3_porcelein_wit
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
General - NLRS_C_content_creator: WISA
Identity Data - Mark: 1531; Type Comments: Wandcloset; Assembly Description: algemeen (verzamelniveau); NLRS_C_code_SfB_tabel1: 74.10; URL: www.wisa-sanitair.com/nl/9100901602; NLRS_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011289&ArtClassVersion=4; Model: Nautic; NLRS_C_type_comments: Wandcloset; NLRS_C_description: Wand WC Gustavsberg 5530 Nautic 4 liter; Manufacturer: WISA; NLRS_C_code_fabrikant_product: 9100901602; NLRS_C_model: Nautic; NLRS_C_revit_versie: 2014; Assembly Code: 4A(74.10); NLRS_C_code_gtin: 8711778125001; NLRS_C_code_ETIM: EC011289; NLRS_C_code_STABU: 53.31; Description: Wand WC Gustavsberg 5530 Nautic 4 liter; NLRS_C_code_fabrikant_gln: 8711778000001
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Dimensions - NLRS_C_hoogte: 350 mm; NLRS_C_breedte: 355 mm; NLRS_C_diepte: 525 mm
Mechanical - CWFU: 0; WFU: 0
Materials and Finishes - NLRS_C_materiaal: NLRS_g3_porcelein_wit

# IfcFlowTerminal: wit_wisa_toiletzitting nautic, NLRS_74_PF_FB_toiletzitting nautic_wisa:wit_wisa_toiletzitting nautic:3528944
In: Level 1
Type - ElementType: wit_wisa_toiletzitting nautic; PredefinedType: WCSEAT; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: NLRS_g3_porcelein_wit
Materials and Finishes - NLRS_C_materiaal: NLRS_g3_porcelein_wit
Mechanical - CWFU: 0; WFU: 0
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Level : Level 1
General - NLRS_C_content_creator: WISA
Dimensions - NLRS_C_diepte: 448 mm; NLRS_C_breedte: 355 mm; NLRS_C_hoogte: 40 mm
Identity Data - NLRS_C_code_gtin: 8711778125315; NLRS_C_description: WC zitting tbv Wand WC Gustavsberg 5530 Nautic; NLRS_C_code_STABU: 53.31; NLRS_C_revit_versie: 2014; NLRS_C_code_fabrikant_product: 1409262801; Manufacturer: WISA; NLRS_C_code_ETIM: EC011196; Type Comments: Toiletzitting; NLRS_C_model: Nautic; Description: WC zitting tbv Wand WC Gustavsberg 5530 Nautic; Assembly Code: 4A(74.10); NLRS_C_code_SfB_tabel1: 74.10; NLRS_C_type_comments: Toiletzitting; Model: Nautic; NLRS_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011196&ArtClassVersion=3; Assembly Description: algemeen (verzamelniveau); NLRS_C_code_fabrikant_gln: 8711778000001; Mark: 1532
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xs afbouwpakket_wisa_afbouwpakket, NLRS_74_PF_FB_afbouwpakket xs_wisa:xs afbouwpakket_wisa_afbouwpakket:3535453
In: Level 1
Type - ElementType: xs afbouwpakket_wisa_afbouwpakket; PredefinedType: USERDEFINED; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: NLRS_h2_staal_blauw, NLRS_r2_gips_wit
Dimensions - NLRS_C_hoogte: 1180 mm; NLRS_C_breedte: 1300 mm; breedte: 1300 mm; NLRS_C_diepte: 200 mm
Materials and Finishes - NLRS_C_materiaal_02: NLRS_r2_gips_wit; NLRS_C_materiaal_01: NLRS_h2_staal_blauw
General - NLRS_C_content_creator: WISA
Mechanical - WFU: 0; CWFU: 0
Constraints - Default Elevation: 0 mm; inbouw: no; Host: Reference Plane; Elevation: 0 mm
Identity Data - NLRS_C_revit_versie: 2014; Description: WISA XS afbouwpakket; Assembly Code: 4A(74.22); NLRS_C_model: XS; Assembly Description: ingebouwde sanitaire voorzieningen; NLRS_C_code_STABU: 53.31; Model: XS; NLRS_C_type_comments: Afbouwpakket; NLRS_C_code_fabrikant_gln: 8711778000001; URL: www.wisa-sanitair.com/nl/8050421371; NLRS_C_description: WISA XS afbouwpakket; NLRS_C_code_fabrikant_product: 8050421371; NLRS_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011514&ArtClassVersion=1; NLRS_C_code_SfB_tabel1: 74.22; Type Comments: Afbouwpakket; NLRS_C_code_gtin: 8711778121034; NLRS_C_code_ETIM: EC011514; Manufacturer: WISA; Mark: 1533
Phasing - Phase Created: New Construction
Construction - voorwand_dikte: 0 mm; inregel_hoogte: 0 mm; inregel_diepte: 200 mm
Other - calc_inregelhoogte: 0 mm; calc_inregeldiepte: 200 mm; Schedule Level: Level: Level 1; calc_voorwanddikte: 3 mm; origin: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xs wc front 4-2 ltr_wisa_inbouwreservoir, NLRS_74_PF_FB_inbouwreservoir xs wc front 4 2L_wisa:xs wc front 4-2 ltr_wisa_inbouwreservoir:3526339
In: Level 1
Type - ElementType: xs wc front 4-2 ltr_wisa_inbouwreservoir; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: NLRS_h2_staal_blauw, NLRS_n6_PEXa_geel, NLRS_n6_PEXa_wit
Other - kw_hoogte: 85 mm; kw_hoek: 90 deg; origin: 0 mm; calc_voorwanddikte: 3 mm; calc_inregelhoogte: 0 mm; calc_vwa_afstand: 88 mm; calc_draadstangen: 230 mm; calc_inregeldiepte: 200 mm; Schedule Level: Level: Level 1; calc_vwa: 88 mm; calc_vwa_lengte: 222 mm; calc_afst_aansluit_hoek: 88 mm; kw_diepte: 73 mm
Plumbing - vwa_hoek: 0 deg; vwa_diameter_90: no; kw_aansluiting_achter: no; vwa_diameter_110: yes; kw_aansluiting_boven: yes; vwa_lengte: 222 mm; vwa_insteldiepte: 0 mm
Mechanical - System Classification: Sanitary,Domestic Cold Water; CWFU: 0; NLRS_P_c02_belastingswaarde: 0; WFU: 0; NLRS_P_c01_belastingswaarde: 0
Construction - draadstangen_230: yes; voorwand_dikte: 0 mm; inregel_hoogte: 0 mm; inregel_diepte: 200 mm; draadstangen_180: no
Phasing - Phase Created: New Construction
Identity Data - Mark: 1527; URL: www.wisa-sanitair.com/nl/8050452715; NLRS_C_description: WISA XS WC front 4/2 ltr 90/110mm; NLRS_C_type_comments: Inbouwreservoir; NLRS_C_code_fabrikant_product: 8050452715; NLRS_C_model: XS; NLRS_C_code_ETIM: EC010145; Model: XS; NLRS_C_code_gtin: 8711778174498; Assembly Code: 4A(74.22); NLRS_C_code_fabrikant_gln: 8711778000001; Assembly Description: ingebouwde sanitaire voorzieningen; Type Comments: Inbouwreservoir; NLRS_C_revit_versie: 2014; NLRS_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Manufacturer: WISA; Description: WISA XS WC front 4/2 ltr 90/110mm; NLRS_C_code_STABU: 53.31; NLRS_C_code_SfB_tabel1: 74.22
Model Properties - bedieningspaneel: NLRS_74_PF_FB_bedieningspaneel xs_wisa: ▼ kies; hoekbeugelset: no
Constraints - inbouw: no; Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Dimensions - NLRS_P_c02_diameter: 110 mm; NLRS_P_c02_hoek: 0 deg; NLRS_C_diepte: 200 mm; NLRS_C_breedte: 380 mm; NLRS_C_hoogte: 1180 mm; NLRS_P_c01_diameter: 15 mm; rs_C_gast_montagehoogte: 230 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - NLRS_P_c01_omschrijving: c01_kw; NLRS_P_c02_omschrijving: c02_vwa; wateraansluiting: G 1/2
General - NLRS_C_content_creator: WISA
Materials and Finishes - NLRS_C_materiaal_01: NLRS_h2_staal_blauw
Mechanical - Flow - spoel_volume: 0.141259 ft3

# IfcFlowTerminal: xs wc front 6 ltr_wisa_inbouwreservoir, NLRS_74_PF_FB_inbouwreservoir xs wc front 6L_wisa:xs wc front 6 ltr_wisa_inbouwreservoir:3526401
In: Level 1
Type - ElementType: xs wc front 6 ltr_wisa_inbouwreservoir; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: NLRS_h2_staal_blauw, NLRS_n6_PEXa_geel, NLRS_n6_PEXa_wit
Plumbing - vwa_diameter_110: yes; vwa_diameter_90: no; kw_aansluiting_achter: no; vwa_lengte: 222 mm; kw_aansluiting_boven: yes; vwa_insteldiepte: 0 mm; vwa_hoek: 0 deg
Mechanical - System Classification: Sanitary,Domestic Cold Water; NLRS_P_c02_belastingswaarde: 0; CWFU: 0; WFU: 0; NLRS_P_c01_belastingswaarde: 0
Other - kw_diepte: 73 mm; calc_vwa_lengte: 222 mm; calc_draadstangen: 230 mm; calc_vwa: 88 mm; calc_inregelhoogte: 0 mm; origin: 0 mm; kw_hoogte: 85 mm; calc_vwa_afstand: 88 mm; Schedule Level: Level: Level 1; kw_hoek: 90 deg; calc_inregeldiepte: 200 mm; calc_afst_aansluit_hoek: 88 mm; calc_voorwanddikte: 3 mm
Phasing - Phase Created: New Construction
Identity Data - Mark: 1529; Assembly Code: 4A(74.22); Type Comments: Inbouwreservoir; NLRS_C_code_SfB_tabel1: 74.22; NLRS_C_model: XS; NLRS_C_revit_versie: 2014; Model: XS; Manufacturer: WISA; Description: WISA XS WC front 6 ltr 90/110mm; NLRS_C_description: WISA XS WC front 6 ltr 90/110mm; NLRS_C_code_gtin: 8711778178496; NLRS_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; URL: www.wisa-sanitair.com/nl/8050452740; NLRS_C_type_comments: Inbouwreservoir; NLRS_C_code_STABU: 53.31; NLRS_C_code_fabrikant_product: 8050452740; NLRS_C_code_ETIM: EC010145; NLRS_C_code_fabrikant_gln: 8711778000001; Assembly Description: ingebouwde sanitaire voorzieningen
Construction - draadstangen_180: no; inregel_hoogte: 0 mm; draadstangen_230: yes; voorwand_dikte: 0 mm; inregel_diepte: 200 mm
Dimensions - NLRS_C_diepte: 200 mm; NLRS_P_c02_diameter: 110 mm; NLRS_P_c02_hoek: 0 deg; rs_C_gast_montagehoogte: 230 mm; NLRS_C_breedte: 380 mm; NLRS_C_hoogte: 1180 mm; NLRS_P_c01_diameter: 15 mm
Model Properties - bedieningspaneel: NLRS_74_PF_FB_bedieningspaneel xs_wisa: ▼ kies; hoekbeugelset: no
Constraints - inbouw: no; Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - NLRS_P_c01_omschrijving: c01_kw; NLRS_P_c02_omschrijving: c02_vwa; wateraansluiting: G 1/2
Materials and Finishes - NLRS_C_materiaal_01: NLRS_h2_staal_blauw
General - NLRS_C_content_creator: WISA
Mechanical - Flow - spoel_volume: 0.211888 ft3

# IfcMember: 74_WISA_logo, 74_WISA_logo:74_WISA_logo:2646220
In: Level 1
Type - ElementType: 74_WISA_logo; Classification:  (UniFormat); Material: WISA blauw
Constraints - Moves With Nearby Elements: no; Level: Level: Level 1; Host: Level : Level 1; Offset: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 4.01625 ft3
Pset_MemberCommon - Reference: 74_WISA_logo; LoadBearing: yes; IsExternal: no; Span: 50 mm; Slope: 0 deg
